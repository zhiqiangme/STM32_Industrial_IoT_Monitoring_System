# Keil uVision project Project.with_bootloader_backup.uvprojx, settings and files
target App_A (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08008000,0x00076800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: App_A +hex
  AfterMake: "C:\Users\Mydei\AppData\Local\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe" --bin --output ".\Objects\App_A\App_A.bin" ".\Objects\App_A\App_A.axf"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,LFS_NO_MALLOC,LFS_NO_ASSERT,LFS_NO_DEBUG,LFS_NO_WARN
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\User;..\BSP;..\System;..\APP;..\LittleFS;..\rt-thread\include;..\rt-thread\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x3b000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f1xx_hal_conf.h stm32f1xx_it.c
  group BSP
    ../BSP/: LED.c Key.c OLED.c OLED_Data.c Flowmeter.c Modbus_Master.c Temperature.c Weight.c Relay.c Modbus_Slave.c G780s.c Upgrade.c W25Q128.c DataLogger.c
  group LittleFS
    ../LittleFS/: lfs.c lfs_util.c lfs_port.c
  group System
    ../System/: delay.c sys.c usart.c tim2.c nanomodbus.c ymodem.c
  group RT-Thread
    ../rt-thread/bsp/: rtconfig.h board.c
    ../rt-thread/src/: clock.c components.c idle.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
    ../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Drivers\CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers\STM32F1xx_HAL _Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Drivers\CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers\STM32F1xx_HAL _Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Bootloader
    ../Bootloader/: boot_flash.c boot_main.c boot_protocol.c boot_sha256.c boot_verify.c bootloader.c main.c stm32f1xx_it.c system_stm32f1xx.c
target App_B (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: App_B +hex
  AfterMake: "C:\Users\Mydei\AppData\Local\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe" --bin --output ".\Objects\App_B\App_B.bin" ".\Objects\App_B\App_B.axf"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8043000 size 0x3b000
  memory RVCT9: RAM 0x20000000 size 0x10000
target Bootloader (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: Bootloader +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\User;..\BSP;..\System;..\APP;..\LittleFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
